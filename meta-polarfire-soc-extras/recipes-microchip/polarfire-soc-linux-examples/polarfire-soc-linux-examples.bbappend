EXAMPLE_FILES:append:icicle-kit-es = "\
    opcua/icicle-kit \
    "

EXAMPLE_FILES:append:mpfs-video-kit = "\
    opcua/video-kit \
    multimedia/v4l2 \
    multimedia/v4l2/auto_enhance_osd/ \
    "

