SYSTEMTAP_riscv64 = "systemtap"

RDEPENDS_${PN}_remove = "lttng-ust"
RDEPENDS_${PN}_remove = "lttng-tools"
RDEPENDS_${PN}_remove = "lttng-modules"
RDEPENDS_${PN}_remove = "babeltrace"
