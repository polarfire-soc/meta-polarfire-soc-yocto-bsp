# Resolve conflict with buysbox
# See: http://lists.openembedded.org/pipermail/openembedded-core/2019-December/290159.html
ALTERNATIVE_${PN}_append = " vlock"
