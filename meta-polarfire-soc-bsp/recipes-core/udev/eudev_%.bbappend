SSTATE_ALLOW_OVERLAP_FILES += "${DEPLOY_DIR_SPDX}"
