require genimage.inc

SRC_URI[sha256sum] = "a8756e3567a0d4d82c36b08ccc1e088250b9006d5670c6b2b014185e6ec60671"
