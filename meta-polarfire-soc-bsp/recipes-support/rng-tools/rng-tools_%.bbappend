PACKAGECONFIG:remove = "libjitterentropy"