SUMMARY = "Device Tree Overlay for BSPs"
DESCRIPTION = "Device Tree Overlay generation and packaging for BSP"
SECTION = "bsp"

COMPATIBLE_MACHINE = "beaglev-fire"


