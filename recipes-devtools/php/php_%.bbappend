PACKAGECONFIG:append:mpfs-video-kit = " apache2"
